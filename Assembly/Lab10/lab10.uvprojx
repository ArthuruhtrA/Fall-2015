# Keil uVision project lab10.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lab10
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: MKL46Z4.s start.s lab10.s
